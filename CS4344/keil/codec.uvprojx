# Keil uVision project codec.uvprojx, settings and files
target codec (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: codec +hex
  AfterMake: fromelf.exe --bin -o ./codec.bin ./obj/codec.axf
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\init;..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\uCOS\Arch;..\lib\uCOS\Bsp;..\lib\uCOS\Source;..\config;..\lib\Mp3Lib;..\lib\Mp3Lib\pub;..\lib\Mp3Lib\real;..\lib\Mp3Lib\real\arm;..\drivers\inc;..\utils\inc;..\lib\fatfs
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../init/: main.c stm32f10x_it.c system_stm32f10x.c
  group utils
    ../utils/src/: delay.c Sys_Delay.c
  group fatfs
    ../lib/fatfs/: diskio.c Fatfs_Api.c ff.c
  group ucosii
    ../lib/uCOS/Arch/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../lib/uCOS/Bsp/: bsp.c
    ../lib/uCOS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group drivers
    ../drivers/src/: cs4344.c Driver_Usart.c Retarget.c sdcard.c
  group CMSIS
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STLibs
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group MP3dec
    ../lib/Mp3Lib/: mp3_play.c mp3dec.c mp3tabs.c
    ../lib/Mp3Lib/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../lib/Mp3Lib/real/arm/: asmmisc.S asmpoly_thumb2.S
software components: CMSIS:CORE 5.1.1
